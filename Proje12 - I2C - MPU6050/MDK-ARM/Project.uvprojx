# Keil uVision project Project.uvprojx, settings and files
target STM32F070RB-Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F070RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: STM32F070RB-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F070xB,USE_HAL_DRIVER,USE_STM32F0XX_NUCLEO
  c misc: --C99
  c include: ../Inc;../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../Drivers/STM32F0xx_HAL_Driver/Inc;../../Drivers/BSP/STM32F0xx-Nucleo;../../Drivers/BSP/Components/Common;../../Utilities/Log;../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Example/User
    ../Src/: main.c stm32f0xx_it.c sd_hal_mpu6050.c
  group Example/MDK-ARM
    ./: startup_stm32f070xb.s
  group Drivers/STM32F0xx_HAL_Driver
    ../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_cortex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_adc.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c
  group Drivers/UART
    ../Src/: uart_buffer.c uart_driver.c
  group Drivers/Button_Led
    ../Src/: button_driver.c led_driver.c
  group Drivers/ADC
    ../Src/: adc_driver.c
  group Drivers/Timer
    ../Src/: timer_driver.c
software components: CMSIS:CORE 4.3.0
